# Keil uVision project jls44_a1.uvprojx, settings and files
target jls44_a1 (ARM-ADS)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.pdsc
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: jls44_a1
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KPSDK_CODE --split_sections -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_MCU_K64F --no_rtti -DARM_MATH_CM4 -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DMBED_BUILD_TIMESTAMP=1498480569.24 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DTARGET_FRDM -DFEATURE_STORAGE=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DDEVICE_SERIAL=1 -DTARGET_KPSDK_MCUS -DTARGET_Freescale -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTARGET_MCUXpresso_MCUS -DDEVICE_LOWPOWERTIMER=1 -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -D__CMSIS_RTOS --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DDEVICE_TRNG=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_K64F -DCPU_MK64FN1M0VMD12 -DDEVICE_STORAGE=1 -DDEVICE_PORTIN=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -DFSL_RTOS_MBED -DDEVICE_SPI_ASYNCH=1 -D__MBED_CMSIS_RTOS_CM
  c include: .; Libraries; Libraries/C12832; Libraries/FXOS8700Q; Libraries/FXOS8700Q/MotionSensor; Libraries/LM75B; Libraries/eCompass_FPU_Lib; include; src; mbed/.; mbed/TARGET_K64F; mbed/TARGET_K64F/TARGET_Freescale; mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS; mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F; mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/TARGET_FRDM; mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device; mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/drivers; mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api; mbed/TARGET_K64F/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/MK64FN1M0xxx12.sct
  group include
    include/: Compass.h LCD.h LED.h SensorData.h Speaker.h TemperatureSensor.h
  group jls44_a1
    ./: mbed_config.h
  group Libraries
    Libraries/C12832/: C12832.cpp C12832.h GraphicsDisplay.cpp GraphicsDisplay.h Small_7.h TextDisplay.cpp TextDisplay.h
    Libraries/eCompass_FPU_Lib/: eCompass_FPU.ar eCompass_Lib.cpp eCompass_Lib.h
    Libraries/FXOS8700Q/: FXOS8700Q.cpp FXOS8700Q.h
    Libraries/LM75B/: LM75B.cpp LM75B.h
    Libraries/FXOS8700Q/MotionSensor/: MotionSensor.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o cmsis_nvic.o crc.o dma_api.o fsl_adc16.o fsl_clock.o fsl_clock_config.o fsl_cmp.o fsl_cmt.o fsl_common.o fsl_crc.o fsl_dac.o fsl_dmamux.o fsl_dspi.o fsl_dspi_edma.o fsl_edma.o fsl_enet.o fsl_ewm.o fsl_flash.o fsl_flexbus.o fsl_flexcan.o fsl_ftm.o fsl_gpio.o fsl_i2c.o fsl_i2c_edma.o fsl_llwu.o fsl_lptmr.o fsl_mpu.o fsl_pdb.o fsl_phy.o fsl_pit.o fsl_pmc.o fsl_rcm.o fsl_rnga.o fsl_rtc.o fsl_sai.o fsl_sai_edma.o fsl_sdhc.o fsl_sim.o fsl_smc.o fsl_uart.o fsl_uart_edma.o fsl_vref.o fsl_wdog.o gpio_api.o gpio_irq_api.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o retarget.o rtc_api.o serial_api.o sleep.o spi_api.o startup_MK64F12.o storage_driver.o sys.o system_MK64F12.o trng_api.o us_ticker.o
    mbed/TARGET_K64F/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_stats.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/: cmsis.h cmsis_nvic.h fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/TARGET_FRDM/: crc.h device.h fsl_clock_config.h fsl_phy.h PeripheralNames.h PinNames.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api/: dma_api_hal.h gpio_object.h objects.h PeripheralPins.h PortNames.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/: dma_reqs.h peripheral_clock_defines.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/drivers/: fsl_adc16.h fsl_clock.h fsl_cmp.h fsl_cmt.h fsl_common.h fsl_crc.h fsl_dac.h fsl_dmamux.h fsl_dspi.h fsl_dspi_edma.h fsl_edma.h fsl_enet.h fsl_ewm.h fsl_flash.h fsl_flexbus.h fsl_flexcan.h fsl_ftm.h fsl_gpio.h fsl_i2c.h fsl_i2c_edma.h fsl_llwu.h fsl_lptmr.h fsl_mpu.h fsl_pdb.h fsl_pit.h fsl_pmc.h fsl_port.h fsl_rcm.h fsl_rnga.h fsl_rtc.h fsl_sai.h fsl_sai_edma.h fsl_sdhc.h fsl_sim.h fsl_smc.h fsl_uart.h fsl_uart_edma.h fsl_vref.h fsl_wdog.h
    mbed/: mbed.h
    mbed/TARGET_K64F/TARGET_Freescale/: mbed_rtx.h
  group src
    src/: Compass.cpp LCD.cpp LED.cpp main.cpp SensorData.cpp Speaker.cpp TemperatureSensor.cpp
